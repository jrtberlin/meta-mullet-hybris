RDEPENDS:${PN}:append:mullet = " geoclue-provider-hybris "
RDEPENDS:${PN}:append:firefish = " geoclue-provider-hybris "
