FILESEXTRAPATHS:prepend:mullet := "${THISDIR}/asteroid-launcher:"
SRC_URI:append:mullet = " file://default.conf"

FILESEXTRAPATHS:prepend:firefish := "${THISDIR}/asteroid-launcher:"
SRC_URI:append:firefish = " file://default.conf"
