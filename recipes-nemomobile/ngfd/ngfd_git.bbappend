RDEPENDS:${PN}:append:mullet = " ngfd-plugin-droid-vibrator "
RDEPENDS:${PN}:append:firefish = " ngfd-plugin-droid-vibrator "
