FILESEXTRAPATHS:prepend:mullet := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE:mullet = "mullet"

FILESEXTRAPATHS:prepend:firefish := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE:firefish = "firefish"